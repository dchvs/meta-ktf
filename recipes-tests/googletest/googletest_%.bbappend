
EXTRA_OECMAKE:append = " \
        -DBUILD_SHARED_LIBS=ON \
"
