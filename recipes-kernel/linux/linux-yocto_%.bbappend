
FILESEXTRAPATHS_prepend := "${THISDIR}/files/fragments:"

SRC_URI += "\
    file://ktf_fragments.scc \
"
